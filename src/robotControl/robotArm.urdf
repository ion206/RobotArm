Commit message: working profile and major RC changes

File: src/robotControl/robotArm.urdf (robot description, URDF)
Before this commit: robot robot_arm, 5 links, 4 joints
Joints:
- joint elbow_joint: limit lower=-1.57 upper=3.14 -> lower=0 upper=3.14
